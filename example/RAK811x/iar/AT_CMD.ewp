# IAR project AT_CMD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050, Pe167,Pe231,Pe513,Pe223
  ICCARM.CCIncludePath2: ..\..\..\..\..\Nuvoton\NANO100B_Series_CMSIS_BSP_EN_Rev1.00.005\Libraries\CMSIS\Include; ..\..\..\..\..\Nuvoton\NANO100B_Series_CMSIS_BSP_EN_Rev1.00.005\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\..\Nuvoton\NANO100B_Series_CMSIS_BSP_EN_Rev1.00.005\Libraries\NANO1xx_Drivers\Include; ..\src\app\custom; ..\..\..\uC-CPU; ..\..\..\uC-CPU\ARM-Cortex-M0\IAR; ..\..\..\uC-LIB; ..\..\..\uCOS-III\Source; ..\..\..\uCOS-III\Cfg\ARM-Cortex-M0; ..\..\..\uCOS-III\Ports\ARM-Cortex-M0\Generic\IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AT_CMD.bin
configuration Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L151CB ST STM32L151CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  ICCARM.CCDefines: STM32L151xB; USE_DEBUGGER; SX1276_CHIP; _USE_NO_TIMER; _REGION_US915; _REGION_AS923; REGION_EU868; _USE_BOOTLOADER
  ICCARM.CCIncludePath2: ..\app; ..\..\..\common\JSON; ..\..\..\LoRaWAN\mac; ..\..\..\LoRaWAN\radio; ..\..\..\LoRaWAN\utils; ..\..\..\hal; ..\..\..\hal\cmsis; ..\..\..\LoRaWAN\system; ..\..\..\LoRaWAN\system\crypto; ..\..\..\platform\STM32\cmsis; ..\..\..\platform\STM32\STM32L1xx_HAL_Driver\Inc; ..\..\..\LoRaWAN\mac\region
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: RAK811_Waterlevel.bin
  ILINK.IlinkOutputFile: AT_CMD.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../app/: app.c app.h at_cmd.c lora_config.c lora_event.c partition.c rw_assert.c rw_lora.c test_pwr.c test_rtc.c
    ../../../common/: iarwrite.c
    ../../../platform/STM32/STM32L1xx_HAL_Driver/Src/: test.c
  group CMSIS
    ../../../hal/cmsis/arm-iar/: startup_stm32l151xb.s
    ../../../hal/cmsis/: system_stm32l1xx.c
  group crypto
    ../../../LoRaWAN/system/crypto/: aes.c cmac.c
  group JSON
    ../../../common/JSON/: cJSON.c
  group Libraries
    ../../../platform/STM32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_msp_template.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c
  group LoRAWAN/hal
    ../../../hal/: adc-board.c board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c sx1276-board.c sx127X-board.c uart-board.c
    ../../../LoRaWAN/system/: fifo.c
  group LoRAWAN/mac
    ../../../LoRaWAN/mac/: LoRaMac.c LoRaMacCrypto.c
  group LoRAWAN/mac/region
    ../../../LoRaWAN/mac/region/: Region.c Region.h RegionAS923.c RegionAS923.h RegionAU915.c RegionAU915.h RegionCN470.c RegionCN470.h RegionCN779.c RegionCN779.h RegionCommon.c RegionCommon.h RegionEU433.c RegionEU433.h RegionEU868.c RegionEU868.h RegionIN865.c RegionIN865.h RegionKR920.c RegionKR920.h RegionUS915-Hybrid.c RegionUS915-Hybrid.h RegionUS915.c RegionUS915.h
  group LoRAWAN/radio
    ../../../LoRaWAN/radio/sx1272/: sx1272.c
    ../../../LoRaWAN/radio/sx1276/: sx1276.c
    ../../../LoRaWAN/radio/: sx127x.c
  group LoRAWAN/system
    ../../../LoRaWAN/system/: adc.c delay.c gpio.c i2c.c timer.c
  group LoRAWAN/utils
    ../../../LoRaWAN/utils/: utilities.c
  group test
    ../../../platform/NANO/NANO100B_Series_CMSIS_BSP_EN_Rev1.00.005/Samples/Driver/RTC/: main.c nano1xx_isr.c
